Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-24T14:25:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 24 14:25:35 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{FF7C72E0-23E1-4D01-AE09-65570DF9FEE5}\ifc * Database version: 5507 * Database creation date: Wed Jun 24 14:25:34 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 24 14:25:35 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 24 14:25:35 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Softshell Side Chair - Basic Dark, Furniture_Chairs_Vitra_Softshell_Side_Chair:Softshell Side Chair - Basic Dark:348256
In: Level 1
Type - Material: Leather umbra grey 61, Basic dark powder-coated 30
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Softshell_Side_Chair; ConvergoRefNr: 0089-2006-0031-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: The Softshell Side Chair, whose gentle contours are defined by its soft upholstery, provides exceptionally comfortable seating and compact dimensions: vertical ribs concealed in the upper part of the backrest offer flexibility and considerable freedom of movement – and exceptional comfort even over prolonged periods of sitting.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Collection: Softshell; Cost: 0; Description: The Softshell Side Chair, whose gentle contours are defined by its soft upholstery, provides exceptionally comfortable seating and compact dimensions: vertical ribs concealed in the upper part of the backrest offer flexibility and considerable freedom of movement – and exceptional comfort even over prolonged periods of sitting.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Softshell Side Chair - Basic Dark; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191441/storage/master/download/Factsheet%20Softshell%20Chair-EN.pdf; Type Name: Softshell Side Chair - Basic Dark; URL: https://www.vitra.com/en-un/living/product/details/softshell-side-chair
Type - Materials and Finishes(Type) - ChairMainMaterial: Leather umbra grey 61; ChairSecondaryMaterial: Basic dark powder-coated 30
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Office Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Softshell_Side_Chair; Features: n/a; Finish: Backrest and seat: seat and backrest shell in fibreglass-reinforced polyamide, flexible upper backrest shell. Seat and backrest upholstery in polyurethane foam. Four-legged base: polyamide in chocolate or basic dark with glides.; Grade: n/a; Material: Plastic, textile/leather; ModelNumber: n/a; ModelReference: 09153902; Name: Vitra_Softshell_Side_Chair; ReplacementCost: n/a; Shape: Sculptured; Size: 490x550x825 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 09153902; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.1275 m2; Volume: 0.222337 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Softshell_Side_Chair: Softshell Side Chair - Basic Dark; Family and Type: Furniture_Chairs_Vitra_Softshell_Side_Chair: Softshell Side Chair - Basic Dark; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Softshell_Side_Chair: Softshell Side Chair - Basic Dark; Type Id: Furniture_Chairs_Vitra_Softshell_Side_Chair: Softshell Side Chair - Basic Dark; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
